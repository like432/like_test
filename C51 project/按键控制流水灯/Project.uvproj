# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Function
  group Function
    ./Function/: Delay.c Delay.h Nixie.c Nixie.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h Key.c Key.h Timer0.c Timer0.h
  group User
    ./User/: main.c
